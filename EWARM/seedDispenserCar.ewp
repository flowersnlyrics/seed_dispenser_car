# IAR project seedDispenserCar.ewp, settings and files
configuration seedDispenserCar (ARM, debug)
  General.OGChipSelectEditMenu: STM32L432KC ST STM32L432KC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L432xx
  ICCARM.CCIncludePath2: ../Inc; ../car_ctrl; ../mill_ctrl; ../wheel_ctrl; ../blade_ctrl; ../if_adapters; ../if_adapters/accel_if/; ../if_adapters/gyro_if/; ../if_adapters/mag_if/; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/LSM9DS1_Driver/Src; ../Drivers/LSM9DS1_Driver/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: seedDispenserCar.hex
  ILINK.IlinkOutputFile: seedDispenserCar.out
  ILINK.IlinkIcfFile: stm32l432xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/car_ctrl
    ../car_ctrl/: car_ctrl.c car_ctrl.h
  group Application/car_ctrl/wheel_ctrl
    ../wheel_ctrl/: wheel_ctrl.c wheel_ctrl.h
  group Application/if_adapters/accel_if
    ../if_adapters/accel_if/: accel_if.c accel_if.h accel_regs.h
  group Application/if_adapters/mag_if
    ../if_adapters/mag_if/: mag_if.c mag_if.h mag_regs.h
  group Application/User
    ../Src/: freertos.c gpio.c i2c.c main.c spi.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c tim.c usart.c
  group Application/wheel_ctrl
    ../mill_ctrl/: mill_ctrl.c
  group Application/wheel_ctrl/blade_ctrl
    ../blade_ctrl/: blade_ctrl.c blade_ctrl.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/LSM9DS1_Driver
    ../Drivers/LSM9DS1_Driver/Src/: LSM9DS1_Driver.c
  group Drivers/LSM9DS1_Driver/Inc
    ../Drivers/LSM9DS1_Driver/Inc/: LSM9DS1_Driver.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group EWARM
    ./: startup_stm32l432xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
